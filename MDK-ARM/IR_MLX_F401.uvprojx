# Keil uVision project IR_MLX_F401.uvprojx, settings and files
target IR_MLX_F401 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: IR_MLX_F401 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xC
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\My_lib\delay;..\My_lib\IIC;..\My_lib\MLX90640;..\My_lib\USART
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: IR_MLX_F401\IR_MLX_F401.sct
  group Application/MDK-ARM
    ./: startup_stm32f401xc.s
  group Application/User
    ../Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f4xx.c
  group My_Lib
    ../My_lib/delay/: delay.c
    ../My_lib/USART/: USART.c
    ../My_lib/IIC/: MLX90640_SWI2C_Driver.c
    ../My_lib/MLX90640/: MLX90640_API.c
software components: CMSIS:CORE 5.1.2
